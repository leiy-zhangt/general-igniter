# Keil uVision project igniter.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: GD32E230G8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: igniter +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: ..\Basic\Include;..\CMSIS\Include;..\Hardware\fuse;..\Hardware\gd32it;..\Hardware\key;..\Hardware\led;..\Hardware\systick;..\Hardware\timer;..\Hardware\trigger;..\User;D:\ProgramFile\Keil5\ARM\CMSIS\5.7.0\CMSIS\Core\Include;..\Hardware\pwm
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Basic
    ../Basic/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group CMSIS
    ../CMSIS/Source/: system_gd32e23x.c
  group Hardware
    ../Hardware/fuse/: fuse.c
    ../Hardware/gd32it/: gd32e23x_it.c
    ../Hardware/key/: key.c
    ../Hardware/led/: led.c
    ../Hardware/systick/: systick.c
    ../Hardware/timer/: timer.c
    ../Hardware/trigger/: trigger.c
    ../Hardware/pwm/: pwm.c
  group Startup
    ../Startup/: startup_gd32e23x.s
  group User
    ../User/: main.c
